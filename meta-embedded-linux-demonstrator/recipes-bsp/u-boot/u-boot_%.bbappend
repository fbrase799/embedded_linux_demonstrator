FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://env-ab.cfg"
